# Keil uVision project YSUROBOT.uvprojx, settings and files
target ETROBOT (ARM-ADS)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAN +hex
  c flags: Optim=1 uC99=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\CAN;..\HARDWARE\DBUS;..\IMU\IMU;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\IWDG;..\TASK\BSP;..\TASK\CONTROL;..\TASK\PID;..\TASK\REMOTE;..\HARDWARE\FRICTION;..\HARDWARE\ADC;..\HARDWARE\USART6;..\HARDWARE\LASER;..\IMU\IMU_EX;..\HARDWARE\REFEREE_SYSTEM;..\HARDWARE\USART2;..\HARDWARE\CAN;..\HARDWARE\SUPERDR
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group TASK
    ../TASK/BSP/: bsp.c
    ../TASK/CONTROL/: control.c
    ../TASK/REMOTE/: Remote.c
    ../TASK/PID/: PID.c
  group IMU
    ../IMU/IMU/: imu.c imu_deal.c
    ../IMU/IMU_EX/: imu_ex.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LASER/: laser.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/DBUS/: dbus.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/FRICTION/: friction.c
    ../HARDWARE/USART2/: USART2.c
    ../HARDWARE/SUPERDR/: superDR.c
    ../HARDWARE/REFEREE_SYSTEM/: referee_system.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_iwdg.c stm32f4xx_adc.c
  group CORE
    ../CORE/: startup_stm32f427_437xx.s
  group README
    ../: readme.txt
